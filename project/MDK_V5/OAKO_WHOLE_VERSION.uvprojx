# Keil uVision project OAKO_WHOLE_VERSION.uvprojx, settings and files
target OAKO_WHOLE_VERSION (6220000::V6.22::ARMCLANG)
  device: -AT32F403ACGU7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.2.1
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: oh +hex
  AfterMake: fromelf.exe --bin --output app.bin "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AT32F403ACGU7,USE_STDPERIPH_DRIVER,AT_START_F403A_V1
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\applications\inc;..\..\applications\src;..\..\drivers\inc;..\..\drivers\src;..\..\tools\inc;..\..\tools\src;../../middlewares/freertos/source/include;../../middlewares/freertos/source/portable/memmang;../../middlewares/freertos/source/portable/GCC/ARM_CM4F;..\src\cm_backtrace;..\src\cm_backtrace\Languages
  memory RVCT4: ROM 0x8008000 size 0x78000
  memory RVCT9: RAM 0x20000000 size 0x38000
  link misc: --info stack
  group user
    ../src/: main.c at32f403a_407_wk_config.c at32f403a_407_int.c wk_system.c freertos_app.c include_port.c wk_debug.c wk_i2c.c wk_usart.c wk_gpio.c wk_wdt.c rtc.c version_info.c
    ../../applications/src/: utis.c mqtt_business_task.c md5.c factory_mode.c mobile_monitor.c gt_1208_1404.lib
  group firmware
    ../../libraries/drivers/src/: at32f403a_407_crm.c at32f403a_407_tmr.c at32f403a_407_rtc.c at32f403a_407_gpio.c at32f403a_407_i2c.c at32f403a_407_usart.c at32f403a_407_pwc.c at32f403a_407_adc.c at32f403a_407_spi.c at32f403a_407_dma.c at32f403a_407_flash.c at32f403a_407_crc.c at32f403a_407_wwdt.c at32f403a_407_wdt.c at32f403a_407_exint.c at32f403a_407_misc.c at32f403a_407_usb.c at32f403a_407_acc.c at32f403a_407_can.c at32f403a_407_dac.c at32f403a_407_xmc.c at32f403a_407_emac.c at32f403a_407_sdio.c at32f403a_407_debug.c at32f403a_407_bpr.c
  group cmsis
    ./: startup_at32f403a_407.s
    ../../libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
  group applications
    ../../applications/src/: user_task.c hp203b.c hpw6862i.c mainprocess.c mqttsend.c watchdog_task.c button_task.c ota_mcu.c
  group drivers
    ../../drivers/src/: user_uart.c i2c_application.c delay.c soft_i2c.c valve_control.c led_colour.c spi_flash.c gt_adc.c drv_led.c user_time.c user_flash.c multi_button.c
  group tools
    ../../tools/src/: data_process.c sn_tool.c
  group middlewares/freertos
    ../../middlewares/freertos/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c stream_buffer.c
    ../../middlewares/freertos/source/portable/memmang/: heap_4.c
  group cm_backtrace
    ../src/cm_backtrace/fault_handler/keil/: cmb_fault.S
    ../src/cm_backtrace/: cm_backtrace.c
